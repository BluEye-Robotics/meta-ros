DESCRIPTION = "Transmission Interface."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=9fe507396161b9e47d2b1e01c422787a"

DEPENDS = "hardware-interface cmake-modules libtinyxml pluginlib resource-retriever roscpp"

require ros-control.inc
