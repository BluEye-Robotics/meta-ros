DESCRIPTION = "Collection of cmake/make build tools primarily for ecl development itself"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"
SRC_URI[md5sum] = "97b802f1277df951b7fea53379545472"
SRC_URI[sha256sum] = "6133fdac73fbedffae19ec5ec6b203225f7e8db9ac1d88fca425d95dc97beae4"

DEPENDS = "ecl-license"

require ecl-tools.inc
