EXTRA_OECMAKE_append = " -DWITH_OPENGL=OFF"
