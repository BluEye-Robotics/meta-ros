DEPENDS += "python-pyyaml python3-pyyaml"
